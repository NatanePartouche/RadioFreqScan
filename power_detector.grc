options:
  parameters:
    generate_options: qt_gui
    id: power_detector
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: tune_freq
  id: variable_qtgui_range
  parameters:
    label: Tuning Frequency
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 100.1e6
  states: {state: disabled}
- name: tune_freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: 240e3
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: 1/50000
    type: float
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: 2.4e6
    type: fir_filter_ccf
    width: 100e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: 2.4e6
    fc: tune_freq
    fftsize: '1024'
    name: '"FM Spectrum"'
    norm_window: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: tune_freq
    freq_correction: '60'
    gain: '29.6'
    samp_rate: 2.4e6
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_probe_signal_x_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_squared_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
